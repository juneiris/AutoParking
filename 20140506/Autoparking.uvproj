# Keil uVision project Autoparking.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Autoparking
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\StartUP;.\StdPeriph_Driver\src;.\User;.\StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: Clock_Init.c main.c stm32f10x_it.c bsp_usart.c bsp_pwm.c bsp_HMC5883L.c bsp_myiic.c bsp_servos.c bsp_ultrasonic.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_tim.c
  group StartUP
    ./StartUP/: startup_stm32f10x_hd.s
